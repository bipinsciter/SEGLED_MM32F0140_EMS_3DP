# Keil uVision project NIYAMA_3DP.uvprojx, settings and files
target GPIO_LED_Toggle (6160000::V6.16::ARMCLANG)
  device: MM32F0141C6P MindMotion
  pack: MindMotion.MM32F0140_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NIYAMA_3DP +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MM32F0140_3DP_Card;..\Device\CMSIS\KEIL_Core;..\Device\MM32F0140\HAL_Lib\Inc;..\Device\MM32F0140\Include;..\Interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../: main.c mm32f0140_it.c platform.c spi_master_polling.c gpio.c wwdg_systemmonitor.c tim1_timebase.c sb_const.h sb_global_var.h sb_variables.h uart_interrupt.c iwdg_systemmonitor.c
    ../Interface/: i2c2master.c i2c3master.c i2cmaster.c TM1680.c PCF8563.c AT45DB321D.c SPI.c XGZP6891D.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../Device/MM32F0140/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../Device/MM32F0140/Source/: system_mm32f0140.c
    ../Device/MM32F0140/Source/KEIL_StartAsm/: startup_mm32f0140_keil.s
